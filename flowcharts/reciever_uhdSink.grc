options:
  parameters:
    author: Quentin Prieels
    category: Custom
    comment: https://github.com/gnuradio/gnuradio/blob/main/gr-digital/examples/ofdm/rx_ofdm.grc
    description: OFDM Communication & radar reciever
    generate_options: qt_gui
    id: reciever_uhdsink
    output_language: python
    title: Reciever with UHD Sink
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: header_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, header_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, n_syms=1, len_tag_key=packet_length_tag_key, frame_len_tag_key=length_tag_key, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=payload_mod.bits_per_symbol(), scramble_header=False)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"frame_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '96'
  states: {}
- name: packet_length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, payload_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols, 1)
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), 0j, (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), 0j, 0j, 0j, 0j, 0j]'
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters: {}
  states: {state: disabled}
- name: usrp_center_freq
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: usrp_gain
  id: variable_qtgui_range
  parameters:
    label: Gain USRP (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: fft_len+fft_len//4
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: payload_mod.bits_per_symbol()
    l: '8'
    len_tag_key: packet_length_tag_key
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_length_tag_key
    packet_len: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    name: Rx Bytes
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: 0 * 1.0/fft_len
    noise_voltage: '0.1'
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod.base()
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_length_tag_key
    packed: 'True'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    guard_interval: fft_len//4
    header_len: '3'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: length_tag_key
    output_symbols: 'True'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    type: complex
  states: {}
- name: digital_ofdm_chanest_vcvc_0
  id: digital_ofdm_chanest_vcvc
  parameters:
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_1
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: payload_equalizer.base()
    fft_len: fft_len
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_serializer_vcc_header
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {}
- name: digital_ofdm_serializer_vcc_payload
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: packet_length_tag_key
    symbols_skipped: '1'
  states: {}
- name: digital_ofdm_sync_sc_cfb_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    threshold: '0.9'
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    log: 'True'
    occupied_carriers: occupied_carriers
    packet_len_key: packet_length_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    rolloff: '0'
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {state: disabled}
- name: digital_packet_headerparser_b_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.base()
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: note_0
  id: note
  parameters:
    note: Timing synchronization
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Header demodulation
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Payload demodulation
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Bytes extraction
  states: {}
- name: note_1
  id: note
  parameters:
    note: USRP Recieving
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    freq0: '0'
    output_rate0: '0'
  states: {state: disabled}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    antenna0: RX1
    bandwidth0: '0'
    block_args: type=x300
    dc_offset0: 'False'
    frequency0: usrp_center_freq
    gain0: usrp_gain
    iq_balance0: 'False'
    rate: samp_rate
  states: {state: disabled}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    issue_stream_cmd: 'True'
    otw: sc16
    output_type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: usrp_center_freq
    gain0: usrp_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: time_domaine
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: time_domaine
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [analog_random_source_x_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', digital_header_payload_demux_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_ofdm_tx_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_2, '0']
- [channels_channel_model_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_packet_headerparser_b_0, '0']
- [digital_constellation_decoder_cb_1, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', blocks_tag_debug_1, '0']
- [digital_header_payload_demux_0, '0', virtual_sink_0, '0']
- [digital_header_payload_demux_0, '1', virtual_sink_1, '0']
- [digital_ofdm_chanest_vcvc_0, '0', digital_ofdm_frame_equalizer_vcvc_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0, '0', digital_ofdm_serializer_vcc_header, '0']
- [digital_ofdm_frame_equalizer_vcvc_1, '0', digital_ofdm_serializer_vcc_payload, '0']
- [digital_ofdm_serializer_vcc_header, '0', digital_constellation_decoder_cb_0, '0']
- [digital_ofdm_serializer_vcc_payload, '0', virtual_sink_1_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '1', digital_header_payload_demux_0, '1']
- [digital_ofdm_tx_0, '0', channels_channel_model_0, '0']
- [digital_packet_headerparser_b_0, header_data, digital_header_payload_demux_0, header_data]
- [fft_vxx_0, '0', digital_ofdm_chanest_vcvc_0, '0']
- [fft_vxx_1, '0', digital_ofdm_frame_equalizer_vcvc_1, '0']
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_rx_streamer_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_ddc_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_ddc_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_rx_radio_0, src_port_id: '0'}
- [uhd_rfnoc_rx_streamer_0, '0', blocks_throttle2_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0, '0', fft_vxx_0, '0']
- [virtual_source_0_0, '0', digital_constellation_decoder_cb_1, '0']
- [virtual_source_1, '0', fft_vxx_1, '0']
- [virtual_source_2, '0', blocks_delay_0, '0']
- [virtual_source_2, '0', digital_ofdm_sync_sc_cfb_0, '0']

metadata:
  file_format: 2
  grc_version: 3.10.11.0
